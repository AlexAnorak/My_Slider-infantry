# Keil uVision project STM32F103C.uvprojx, settings and files
target STM32F103C8T6 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103C +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\Mylib;..\Libraries;..\CM3;..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../User/: main.c stm32f10x_it.c
    ../: README.txt
  group Mylib
    ../Mylib/: encoder.c pwm.c delay.c can.c usart2.c flash.c SysTick.c schedule.c usartBroadcast.c control.c parameter.c spi1.c spi2.c AS5048.c filter.c mymath.c led.c
  group Libraries
    ../Libraries/: misc.c stm32f10x_adc.c stm32f10x_can.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_exti.c stm32f10x_spi.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
