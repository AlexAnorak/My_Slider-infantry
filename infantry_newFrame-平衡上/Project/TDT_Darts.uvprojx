# Keil uVision project TDT_Darts.uvprojx, settings and files
target TDT_Darts (6140000::V6.14::ARMCLANG)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IROM(0x08000000,0x00100000) IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TDT_Darts +hex
  c flags: Optim=1 OneElfS=1 v6Lang=4 v6LangP=4 wLevel=3
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,USE_MAIN_CTRL_2021_PJ
  c misc: -frtti -Wno-invalid-source-encoding
  c include: ..\ST_Lib\inc;..\User;..\DSP_Lib;..\TDT_Bsp\inc;..\TDT_Alg\inc;..\TDT_device\inc;..\TDT_Task\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: main.cpp board.cpp cycle.cpp stm32f4xx_it.c readme.txt schedule.cpp
  group TDT_Task
    ../TDT_Task/src/: task_virtual.cpp imu_task.cpp led_task.cpp ammo_cover_task.cpp autoIntoStation_task.cpp chassis_task.cpp fast_selfCheck.cpp fire_task.cpp gimbal_task.cpp state_task.cpp
  group TDT_Alg
    ../TDT_Alg/src/: pid.cpp crc.cpp filter.cpp imu.cpp my_math.cpp can_calculate.cpp curve_model.cpp mecanum.cpp AHRS_middleware.c AHRS.lib TimeMatch.cpp KeyProcess.cpp parameter.cpp
  group TDT_Bsp
    ../TDT_Bsp/src/: spi.cpp can.cpp iwdg.cpp timer.cpp iic.cpp usart.cpp
    ../TDT_device/src/: vision.cpp
  group TDT_Device
    ../TDT_device/src/: dbus.cpp led.cpp motor.cpp mpu6050.cpp oled.cpp icm20602.cpp icm42605.cpp scha634_03.cpp judgement.cpp multi_imu.cpp
    ../TDT_Device/src/: flash_var.cpp icm20608.cpp
  group ST_Lib
    ../ST_Lib/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c system_stm32f4xx.c
    ../ST_Lib/: startup_stm32f40_41xxx.s
  group DSP_Lib
    ../DSP_Lib/: arm_cortexM4lf_math.lib
